# Keil uVision project rumg.uvprojx, settings and files
target rumg (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rumg +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\SX1278;..\stm32_graphics_display_drivers-master\Drivers\lcd\ili9488;..\stm32_graphics_display_drivers-master\Drivers\stm32f1xx;..\stm32_graphics_display_drivers-master\Drivers;..\Graphics;..\WizneLib\Ethernet\W5500;..\WizneLib\Ethernet
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: analog.c logic.c user_libs.c lora.c parameters.c main.c freertos.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c time_lib.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_iwdg.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group SX1278
    ../SX1278/: SX1278.c SX1278_hw.c
  group Graphics
    ../Graphics/: main_window.c UI_tree.c UI_settings.c UI_log.c UI_plot.c GraphLib.c
  group Display
    ../stm32_graphics_display_drivers-master/Drivers/lcd/ili9488/: ili9488.c
    ../stm32_graphics_display_drivers-master/Drivers/Fonts/: font8.c font12.c font16.c font20.c font24.c
    ../stm32_graphics_display_drivers-master/Drivers/stm32f1xx/: lcd_io_spi.c
    ../stm32_graphics_display_drivers-master/Drivers/: stm32_adafruit_lcd.c
  group Touch
    ../Graphics/: xpt2046.c
  group WizNet
    ../WizneLib/Ethernet/: socket.c wizchip_conf.c
    ../WizneLib/Ethernet/W5500/: w5500.c
    ../WizneLib/Application/loopback/: loopback.c
software components: CMSIS:CORE 4.3.0
